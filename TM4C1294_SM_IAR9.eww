<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\Exerc_21\src\Exerc_21.ewp</path>
    </project>
    <batchBuild />
</workspace>
